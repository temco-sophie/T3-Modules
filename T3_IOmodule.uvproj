# Keil uVision project T3_IOmodule.uvproj, settings and files
target Target 1 (MCS-51)
  device: VRS1000 (VRS1000-40) Goal Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM(0-0x2FF) CLOCK(12000000)
  output: T3-8AO_Rev69 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: T3_IO.c serial1.c pic.c read_outputs.c flash_info.c range.c
    ./Keil_TEMCO_headers/: goal_flash.c
